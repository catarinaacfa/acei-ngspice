** Generated for: Eldo
** Generated on: Feb 27 10:58:28 2013
** Design library name: JoaoMelo
** Design cell name: Folded
** Design view name: Schematic

.OPTION TUNING=FAST
.OPTION AEX

.INC umc130.lib

.GLOBAL
.include 'design_var.inc'
.include 'subCir-Folded.cir'

*********************************************************
** Library name: JoaoMelo
** Cell name: Testbench
** View name: Schematic
xi10 0 net15 vddnet vin vip vout Folded
c0 vout 0 10e-12
v2 vin 0 DC=1.65
v1 vip 0 DC=1.65 AC 1
v0 vddnet 0 DC=_vdd
i1 vddnet net15 DC=100u

xi11 0 net16 vddd vinn vipp voutt Folded
c1 voutt 0 10e-12
v5 vipp 0 DC=1.65
v4 vinn 0 DC=1.65
v3 vddd 0 DC=_vdd AC 1
i2 vddd net16 DC=100u
*********************************************************

*********** Analysis ***************************
.TEMP 25.0
.OPTION BRIEF=0
************************************************

.control

set units = degrees

AC DEC 200 1 1G

let IDD = @v0[i]
print IDD

meas AC GDC FIND vdb(vout) at=1
meas AC GBW WHEN vdb(vout)=0
meas AC PM_Negative FIND vp(vout) WHEN vdb(vout)=0
meas AC GPS FIND vdb(voutt) at=1

let FOM = ((GBW/1000000)*10)/(IDD*1000)
print FOM

let PM = PM_Negative + 180
print PM

let PSRR = GDC-GPS
print PSRR

let outswing = 1.65 - @m.xi10.mnm6[vdsat] - @m.xi10.mnm8[vdsat]
print outswing

let vov_mpm0 = @m.xi10.mpm0[vgs] - @m.xi10.mpm0[vth]
print vov_mpm0

let vov_mpm1 = @m.xi10.mpm1[vgs] - @m.xi10.mpm1[vth]
print vov_mpm1

let vov_mpm3 = @m.xi10.mpm3[vgs] - @m.xi10.mpm3[vth]
print vov_mpm3

let vov_mpm4 = @m.xi10.mpm4[vgs] - @m.xi10.mpm4[vth]
print vov_mpm4

let vov_mpm5 = @m.xi10.mpm5[vgs] - @m.xi10.mpm5[vth]
print vov_mpm5

let vov_mpm6 = @m.xi10.mpm6[vgs] - @m.xi10.mpm6[vth]
print vov_mpm6

let vov_mnm1 = @m.xi10.mnm1[vgs] - @m.xi10.mnm1[vth]
print vov_mnm1

let vov_mnm2 = @m.xi10.mnm2[vgs] - @m.xi10.mnm2[vth]
print vov_mnm2

let vov_mnm3 = @m.xi10.mnm3[vgs] - @m.xi10.mnm3[vth]
print vov_mnm3

let vov_mnm4 = @m.xi10.mnm4[vgs] - @m.xi10.mnm4[vth]
print vov_mnm4

let vov_mnm5 = @m.xi10.mnm5[vgs] - @m.xi10.mnm5[vth]
print vov_mnm5

let vov_mnm6 = @m.xi10.mnm6[vgs] - @m.xi10.mnm6[vth]
print vov_mnm6

let vov_mnm7 = @m.xi10.mnm7[vgs] - @m.xi10.mnm7[vth]
print vov_mnm7

let vov_mnm8 = @m.xi10.mnm8[vgs] - @m.xi10.mnm8[vth]
print vov_mnm8

let delta_mpm0 = @m.xi10.mpm0[vds] - @m.xi10.mpm0[vdsat]
print delta_mpm0

let delta_mpm1 = @m.xi10.mpm1[vds] - @m.xi10.mpm1[vdsat]
print delta_mpm1

let delta_mpm3 = @m.xi10.mpm3[vds] - @m.xi10.mpm3[vdsat]
print delta_mpm3

let delta_mpm4 = @m.xi10.mpm4[vds] - @m.xi10.mpm4[vdsat]
print delta_mpm4

let delta_mpm5 = @m.xi10.mpm5[vds] - @m.xi10.mpm5[vdsat]
print delta_mpm5

let delta_mpm6 = @m.xi10.mpm6[vds] - @m.xi10.mpm6[vdsat]
print delta_mpm6

let delta_mnm1 = @m.xi10.mnm1[vds] - @m.xi10.mnm1[vdsat]
print delta_mnm1

let delta_mnm2 = @m.xi10.mnm2[vds] - @m.xi10.mnm2[vdsat]
print delta_mnm2

let delta_mnm3 = @m.xi10.mnm3[vds] - @m.xi10.mnm3[vdsat]
print delta_mnm3

let delta_mnm4 = @m.xi10.mnm4[vds] - @m.xi10.mnm4[vdsat]
print delta_mnm4

let delta_mnm5 = @m.xi10.mnm5[vds] - @m.xi10.mnm5[vdsat]
print delta_mnm5

let delta_mnm6 = @m.xi10.mnm6[vds] - @m.xi10.mnm6[vdsat]
print delta_mnm6

let delta_mnm7 = @m.xi10.mnm7[vds] - @m.xi10.mnm7[vdsat]
print delta_mnm7

let delta_mnm8 = @m.xi10.mnm8[vds] - @m.xi10.mnm8[vdsat]
print delta_mnm8

quit

.endc

.END
